Commit message: Fix urdf & paly rate

File: cartographer_ros/urdf/slam_3d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_3d, 4 links, 3 joints
Joints:
- joint head/main: origin xyz=-0.04 0.03 0 rpy=-1.5708 -1.5708 0 -> xyz=0.04 -0.03 0 rpy=0 -1.5708 -1.5708
